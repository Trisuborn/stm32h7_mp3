# Keil uVision project h7mp3.uvprojx, settings and files
target art-pi (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: art_pi +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,ARM_MATH_ROUNDING,__TARGET_FPU_VFP
  c misc: --locale=english
  c include: ..\core;..\inc;..\inc\cmsis;..\inc\machine;..\inc\math;..\main;.;..\lib\STM32H7xx_HAL_Driver\Inc;..\lib\STM32H7xx_HAL_Driver\Inc\Legacy;.;..\tp\rt-thread\user;..\tp\rt-thread\include;..\tp\rt-thread\include\libc;.;..\tp\rt-thread\components\finsh;..\tp\rt-thread\components\dfs\include;..\tp\rt-thread\components\dfs\filesystems\devfs;..\tp\rt-thread\components\dfs\filesystems\elmfat;..\tp\rt-thread\components\dfs\filesystems\romfs;.;..\tp\rt-thread\components\drivers\include\drivers;..\tp\rt-thread\components\drivers\misc;..\tp\rt-thread\components\drivers\include;..\tp\rt-thread\components\drivers\i2c;..\tp\rt-thread\components\drivers\spi;..\tp\rt-thread\components\drivers\spi\sfud\inc;..\tp\rt-thread\components\drivers\audio;..\tp\rt-thread\components\libc\compilers\common;..\tp\rt-thread\components\libc\compilers\common\sys;..\tp\rt-thread\components\libc\compilers\armlibc;..\tp\rt-thread\components\libc\compilers\armlibc\sys;.;..\tp\rt-thread\bsp\stm32\libraries\HAL_Drivers;..\tp\rt-thread\bsp\stm32\libraries\HAL_Drivers\drv_flash;..\tp\rt-thread\bsp\stm32\libraries\HAL_Drivers\config\h7;..\tp\rt-thread\user\audio
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\core\h7.sct
  group core
    ../core/: stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c startup_stm32h743xx.s h7.sct
  group main
    ../main/: main.c sys_conf.c
  group lib
    ../lib/: arm_cortexM4lf_math.lib arm_cortexM7lfdp_math.lib
    ../lib/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cordic.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_fmac.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pssi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_cordic.c stm32h7xx_ll_crc.c stm32h7xx_ll_crs.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmac.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c stm32h7xx_ll_utils.c
  group rtt/kernel
    ../tp/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ../tp/rt-thread/libcpu/arm/common/: backtrace.c div0.c divsi3.S showmem.c
    ../tp/rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group rtt/finsh
    ../tp/rt-thread/components/finsh/: cmd.c msh.c shell.c msh_file.c
  group rtt/dfs
    ../tp/rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
  group rtt/filesystems
    ../tp/rt-thread/components/dfs/filesystems/elmfat/: ff.c ffconf.h dfs_elm.c ffunicode.c
    ../tp/rt-thread/components/dfs/filesystems/romfs/: romfs.c dfs_romfs.c
    ../tp/rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group rtt/drv
    ../tp/rt-thread/bsp/stm32/libraries/HAL_Drivers/: drv_gpio.c drv_common.c drv_usart.c drv_pwm.c drv_sdio.c drv_spi_ili9488.c drv_spi.c drv_sdram.c drv_soft_i2c.c drv_rtc.c
  group rtt/drv_core
    ../tp/rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    ../tp/rt-thread/components/drivers/serial/: serial.c
    ../tp/rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../tp/rt-thread/components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_msd.c
    ../tp/rt-thread/components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../tp/rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../tp/rt-thread/components/drivers/audio/: audio.c audio_pipe.c
    ../tp/rt-thread/components/drivers/rtc/: rtc.c alarm.c
  group rtt/audio
    ../tp/rt-thread/user/audio/: drv_sound.c wm8988.c
  group rtt/libc
    ../tp/rt-thread/components/libc/compilers/armlibc/: stdio.c stubs.c mem_std.c libc_syms.c libc.c
    ../tp/rt-thread/components/libc/compilers/common/: time.c unistd.c
  group rtt/user
    ../tp/rt-thread/user/: board.c rtconfig.h sdram_port.h lcd_port.h board.h
target minih7 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: h7mp3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: as above
  c misc: --locale=english
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\core\h7.sct
